# Repository MUNAKATA-EPC/Artemis_2024

## KiCad design Project_ForKitakyusyuOpen/Hardware/kicad_data/order/line_board/front/line_front.kicad_pcb

Board: 2 copper layers, 16.0 x 31.5 mm, 4 parts (0 on the bottom side), 5 nets.

Parts:
D5: LED; LED_D5.0mm_Clear
J29: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Horizontal
U8, U9: Line_sennsor; S4282-51

Connections:
+5V: J29.1, U8.2 (VCC), U9.2 (VCC)
D5: J29.3, U8.3 (VOUT), U9.3 (VOUT)
GND: J29.2, U8.4 (GND), U9.4 (GND)
K2(-): D5.1 (K), U8.1 (K(-)), U9.1 (K(-))
LED2: D5.2 (A), J29.4

## KiCad design Project_ForKitakyusyuOpen/Hardware/kicad_data/order/line_board/others/line_others.kicad_pcb

Parts:
D6, D7, D8: LED; LED_D5.0mm_Clear
J30: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Horizontal
U10, U11, U12: Line_sennsor; S4282-51

Connections:
+5V: J30.1, U10.2 (VCC), U11.2 (VCC), U12.2 (VCC)
D6: J30.3, U10.3 (VOUT), U11.3 (VOUT), U12.3 (VOUT)
GND: J30.2, U10.4 (GND), U11.4 (GND), U12.4 (GND)
K2(-): D6.1 (K), D7.1 (K), D8.1 (K), U10.1 (K(-)), U11.1 (K(-)), U12.1 (K(-))
LED2: D6.2 (A), D7.2 (A), D8.2 (A), J30.4

Notes on the sheet:
line

Board: 2 copper layers, 16.0 x 51.5 mm, 7 parts (0 on the bottom side), 5 nets.

## KiCad design Project_ForKitakyusyuOpen/Hardware/kicad_data/order/power2/power_board.kicad_pcb

Parts:
C1, C2: C; C_Disc_D5.1mm_W3.2mm_P5.00mm
J2: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
R1, R2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1: R_Potentiometer_Trim_US; Potentiometer_Bourns_3296W_Vertical
SW1: SW_DIP_x01; 2MS1T2B4M2QES
SW2: SW_DIP_x01; DS-850k
U3: OKL-T_6-W12N-C; DCDC-murata-6A

Connections:
+5V: C2.1, J2.1, U3.4 (VOUT), U3.5 (SENSE)
+12V: J2.3, SW2.1
GND: C1.2, C2.2, J2.2, SW1.1
unnamed: R2.1, RV1.1, RV1.2
unnamed: R2.2, U3.3 (GND), U3.7 (GND)
unnamed: R1.2, SW1.2, U3.1 (ON/OFF_CTRL)
unnamed: RV1.3, U3.6 (TRIM)
unnamed: C1.1, R1.1, SW2.2, U3.2 (VIN)

Notes on the sheet:
power

Board: 2 copper layers, 44.1 x 41.5 mm, 9 parts (0 on the bottom side), 8 nets.

## KiCad design Project_ForRitsumoriCup/Hardware/KiCad_Data/Kicking_Unit/Kicking_Unit.kicad_pcb

Parts:
C1, C4: 220μF; C_Elec_8x10.2
C2, C3: 105; C_0402_1005Metric
C5, C6: C; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
D1, D2: D; D_A-405_P7.62mm_Horizontal
J1, J3: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x04_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: Conn_01x02_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
L1: INDUCTOR 47μH/5A; L_12x12mm_H8mm
Q1, Q2: Q_NJFET_GDS; K15A20D
R1: 470; R_0402_1005Metric
R2: 560; R_0402_1005Metric
R3, R4, R6, R7: R; R_0402_1005Metric
R8: R; 5W 1Ω sement
RV1: 20K; Potentiometer_Bourns_3296W_Vertical
SW1, SW2: SW_Push; SW_PUSH_6mm_H5mm
SW3: SW_DPDT_x2; 2MS1T2B4M2QES
VR1: XL6009; DPAK170P1435X465-6N; PARTREV 1.1

Connections:
+3V3: J2.1, SW1.1, SW2.1
+12V: C1.1, C2.1, D2.1 (K), J3.2, L1.1, VR1.4 (VIN)
+48V: C3.1, C4.1, C5.1, C6.1, D1.1 (K), J1.1, RV1.1
FET1: J2.3, R3.1, R4.1, SW1.2
FET2: J2.4, R6.2, SW2.2
GND: C1.2, C2.2, C3.2, C4.2, J2.2, J3.1, J4.1, Q1.3 (S), R1.1, R2.1, R3.2, VR1.1 (GND)
unnamed: C5.2, C6.2, Q1.2 (D), Q2.3 (S), R7.2
unnamed: D1.2 (A), L1.2, VR1.3 (SW), VR1.6 (SW)
unnamed: D2.2 (A), J4.2
unnamed: J1.2, R8.1
unnamed: Q1.1 (G), R4.2
unnamed: Q2.1 (G), R6.1, R7.1
unnamed: Q2.2 (D), R8.2
unnamed: R1.2, SW3.3 (C)
unnamed: R2.2, SW3.1 (A)
unnamed: RV1.2, RV1.3, SW3.2 (B), VR1.5 (FB)

Notes on the sheet:
Voltage Boosting Circuit
Power input
Kicking_Unit
Kicking controle circuit
signal input
最大55v出力時
最大48v出力時
Fan con

Board: 2 copper layers, 50.0 x 47.9 mm, 27 parts (3 on the bottom side), 16 nets.

## KiCad design Project_ForRitsumoriCup/Hardware/KiCad_Data/Line_sensor/Line_sensor.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: C; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_D3.0mm_Clear
J1: Conn_01x09_Female; PinHeader_1x09_P1.27mm_Vertical
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: Line_sennsor
U17: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, J1.1, U1.2 (VCC), U2.2 (VCC), U3.2 (VCC), U4.2 (VCC), U5.2 (VCC), U6.2 (VCC), U7.2 (VCC), U8.2 (VCC), U9.2 (VCC), U10.2 (VCC), U11.2 (VCC), U12.2 (VCC), U13.2 (VCC), U14.2 (VCC), U15.2 (VCC), U16.2 (VCC), U17.24 (VCC); also elsewhere on the board
Analog: J1.4, U17.1 (COM); also elsewhere on the board
E: J1.7, U17.15 (~E); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.2, U1.4 (GND), U2.4 (GND), U3.4 (GND), U4.4 (GND), U5.4 (GND), U6.4 (GND), U7.4 (GND), U8.4 (GND), U9.4 (GND), U10.4 (GND), U11.4 (GND), U12.4 (GND), U13.4 (GND), U14.4 (GND), U15.4 (GND), U16.4 (GND), U17.12 (GND); also elsewhere on the board
LED: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), J1.3
unnamed: D1.2 (A), U1.1 (K(-))
unnamed: D2.2 (A), U2.1 (K(-))
unnamed: D3.2 (A), U3.1 (K(-))
unnamed: D4.2 (A), U4.1 (K(-))
unnamed: D5.2 (A), U5.1 (K(-))
unnamed: D6.2 (A), U6.1 (K(-))
unnamed: D7.2 (A), U7.1 (K(-))
unnamed: D8.2 (A), U8.1 (K(-))
unnamed: D9.2 (A), U9.1 (K(-))
unnamed: D10.2 (A), U10.1 (K(-))
unnamed: D11.2 (A), U11.1 (K(-))
unnamed: D12.2 (A), U12.1 (K(-))
unnamed: D13.2 (A), U13.1 (K(-))
unnamed: D14.2 (A), U14.1 (K(-))
unnamed: D15.2 (A), U15.1 (K(-))
unnamed: D16.2 (A), U16.1 (K(-))
S0: J1.9, U17.10 (S0); also elsewhere on the board
S1: J1.8, U17.11 (S1); also elsewhere on the board
S2: J1.6, U17.14 (S2); also elsewhere on the board
S3: J1.5, U17.13 (S3); also elsewhere on the board
Sen 1: U1.3 (VOUT), U17.9 (I0); also elsewhere on the board
Sen 2: U3.3 (VOUT), U17.8 (I1); also elsewhere on the board
Sen 3: U5.3 (VOUT), U17.7 (I2); also elsewhere on the board
Sen 4: U7.3 (VOUT), U17.6 (I3); also elsewhere on the board
Sen 5: U9.3 (VOUT), U17.5 (I4); also elsewhere on the board
Sen 6: U11.3 (VOUT), U17.4 (I5); also elsewhere on the board
Sen 7: U13.3 (VOUT), U17.3 (I6); also elsewhere on the board
Sen 8: U15.3 (VOUT), U17.2 (I7); also elsewhere on the board
Sen 9: U2.3 (VOUT), U17.23 (I8); also elsewhere on the board
Sen 10: U4.3 (VOUT), U17.22 (I9); also elsewhere on the board
Sen 11: U6.3 (VOUT), U17.21 (I10); also elsewhere on the board
Sen 12: U8.3 (VOUT), U17.20 (I11); also elsewhere on the board
Sen 13: U10.3 (VOUT), U17.19 (I12); also elsewhere on the board
Sen 14: U12.3 (VOUT), U17.18 (I13); also elsewhere on the board
Sen 15: U14.3 (VOUT), U17.17 (I14); also elsewhere on the board
Sen 16: U16.3 (VOUT), U17.16 (I15); also elsewhere on the board

Board: 2 copper layers, 110.0 x 110.0 mm, 50 parts (0 on the bottom side), 41 nets.

Other parts of the board:
multiplexer: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Their connections:
+3V3: multiplexer.24 (VCC); also elsewhere on the board
Analog: multiplexer.1 (COM); also elsewhere on the board
E: multiplexer.15 (~E); also elsewhere on the board
GND: multiplexer.12 (GND); also elsewhere on the board
S0: multiplexer.10 (S0); also elsewhere on the board
S1: multiplexer.11 (S1); also elsewhere on the board
S2: multiplexer.14 (S2); also elsewhere on the board
S3: multiplexer.13 (S3); also elsewhere on the board
Sen 1: multiplexer.9 (I0); also elsewhere on the board
Sen 2: multiplexer.8 (I1); also elsewhere on the board
Sen 3: multiplexer.7 (I2); also elsewhere on the board
Sen 4: multiplexer.6 (I3); also elsewhere on the board
Sen 5: multiplexer.5 (I4); also elsewhere on the board
Sen 6: multiplexer.4 (I5); also elsewhere on the board
Sen 7: multiplexer.3 (I6); also elsewhere on the board
Sen 8: multiplexer.2 (I7); also elsewhere on the board
Sen 9: multiplexer.23 (I8); also elsewhere on the board
Sen 10: multiplexer.22 (I9); also elsewhere on the board
Sen 11: multiplexer.21 (I10); also elsewhere on the board
Sen 12: multiplexer.20 (I11); also elsewhere on the board
Sen 13: multiplexer.19 (I12); also elsewhere on the board
Sen 14: multiplexer.18 (I13); also elsewhere on the board
Sen 15: multiplexer.17 (I14); also elsewhere on the board
Sen 16: multiplexer.16 (I15); also elsewhere on the board

## KiCad design Project_ForRitsumoriCup/Hardware/KiCad_Data/Motor_Driver/Motor_Driver.kicad_pcb

Parts:
C1, C21: 1000μ; C_Radial_D10.0mm_H20.0mm_P5.00mm
C2, C3, C5, C7, C13, C15, C18, C20, C22, C23, C25, C27, C32, C34, C36, C38: 100n; C_0402_1005Metric
C4, C24: 10n; C_0402_1005Metric
C6, C26: 330μ; C_Elec_10x10.2
C8, C28: C; C_0402_1005Metric
C9, C29: 47μ; CP_Elec_6.3x7.7
C10: 10μ; C_0402_1005Metric
C11, C12, C14, C17, C19, C30, C31, C33, C35, C37: 1μ; C_0402_1005Metric
C16: 22μ; C_0402_1005Metric
D1, D2, D3: D; D_A-405_P7.62mm_Horizontal
J1, J2, J4, J5, J6, J7: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1, R4: 3.3; R_0402_1005Metric
R2, R3, R5, R6: R; R_0402_1005Metric
U1: Seeeduino_Xiao; seeeduinoXIAO
U2, U4: DRV8432DKD; SOP65P1420X360-36N; PARTREV G
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C16.2, D1.2 (A), U1.12 (3V3), U3.2 (VO)
+5V: C10.2, D1.1 (K), D3.1 (K), U3.3 (VI)
+12V: C1.1, C2.1, C3.1, C5.1, C6.1, C7.1, C9.1, C11.1, C12.1, C14.1, C17.1, C19.1, C21.1, C22.1, C23.1, C25.1, C26.1, C27.1, C29.1, C30.1, C31.1, C33.1, C35.1, C37.1, D2.1 (K), J4.2, R1.1, R4.1, U2.1 (GVDD_B), U2.17 (VDD), U2.18 (GVDD_C), U2.19 (GVDD_D), U2.21 (PVDD_D), U2.26 (PVDD_C), U2.29 (PVDD_B), U2.34 (PVDD_A), U2.36 (GVDD_A), U4.1 (GVDD_B), U4.17 (VDD), U4.18 (GVDD_C), U4.19 (GVDD_D), U4.21 (PVDD_D), U4.26 (PVDD_C), U4.29 (PVDD_B), U4.34 (PVDD_A), U4.36 (GVDD_A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.1, C11.2, C12.2, C14.2, C16.1, C17.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C33.2, C35.2, C37.2, J3.2, J4.1, R2.1, R3.2, R5.1, R6.2, U1.13 (GND), U2.6 (PWM_B), U2.9 (AGND), U2.11 (M3), U2.16 (PWM_D), U2.23 (GND_D), U2.24 (GND_C), U2.31 (GND_B), U2.32 (GND_A), U3.1 (GND), U4.6 (PWM_B), U4.9 (AGND), U4.11 (M3), U4.16 (PWM_D), U4.23 (GND_D), U4.24 (GND_C), U4.31 (GND_B), U4.32 (GND_A)
unnamed: C4.1, R1.2
unnamed: C8.2, U2.10 (VREG), U2.12 (M2), U2.13 (M1)
unnamed: C13.1, U2.20 (BST_D)
unnamed: C13.2, J2.2, U2.22 (OUT_D)
unnamed: C15.1, U2.27 (BST_C)
unnamed: C15.2, J2.1, U2.25 (OUT_C)
unnamed: C18.1, U2.28 (BST_B)
unnamed: C18.2, J1.2, U2.30 (OUT_B)
unnamed: C20.1, U2.35 (BST_A)
unnamed: C20.2, J1.1, U2.33 (OUT_A)
unnamed: C24.1, R4.2
unnamed: C28.2, U4.10 (VREG), U4.12 (M2), U4.13 (M1)
unnamed: C32.1, U4.20 (BST_D)
unnamed: C32.2, J6.2, U4.22 (OUT_D)
unnamed: C34.1, U4.27 (BST_C)
unnamed: C34.2, J6.1, U4.25 (OUT_C)
unnamed: C36.1, U4.28 (BST_B)
unnamed: C36.2, J5.2, U4.30 (OUT_B)
unnamed: C38.1, U4.35 (BST_A)
unnamed: C38.2, J5.1, U4.33 (OUT_A)
unnamed: D2.2 (A), J3.1
unnamed: D3.2 (A), J3.3
unnamed: R2.2, U2.8 (GND)
unnamed: R3.1, U2.7 (OC_ADJ)
unnamed: R5.2, U4.8 (GND)
unnamed: R6.1, U4.7 (OC_ADJ)
PWM1: U1.1 (AD0), U2.4 (PWM_A)
PWM2: U1.2 (AD1), U2.14 (PWM_C)
PWM3: U1.3 (AD2), U4.4 (PWM_A)
PWM4: U1.4 (AD3), U4.14 (PWM_C)
RX: J7.1, U1.7 (D6/TX)
Reset1: U1.5 (D4/SDA), U2.5 (~RESET_AB)
Reset2: U1.6 (D5/SCL), U2.15 (~RESET_CD)
Reset3: U1.9 (SCK/D8), U4.5 (~RESET_AB)
Reset4: U1.10 (MISO/D9), U4.15 (~RESET_CD)
TX: J7.2, U1.8 (RX/CS/D7)

Notes on the sheet:
Seeduino
Fan con
Motor Driver Circuit
Power con
Power supply circuit
Regulator to 3.3v
DRV8432 Motor3,4
DRV8432 Motor1,2

Board: 2 copper layers, 58 parts (0 on the bottom side), 40 nets, no tracks yet.

## KiCad design Project_ForRitsumoriCup/Hardware/KiCad_Data/Power_Suply_Unit/Power_Suply_Unit.kicad_pcb

Board: 2 copper layers, 67.1 x 51.0 mm, 25 parts (2 on the bottom side), 14 nets.

Parts:
BAT: Battery; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
C1, C2, C3, C4: C; C_Disc_D4.7mm_W2.5mm_P5.00mm
CON_RV: R_Potentiometer_Trim_US; Potentiometer_Bourns_3296W_Vertical
D1: D_Shockley; D_5W_P12.70mm_Horizontal
F1: Fuse; fuse_socket
J1, J2, J3, J4: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5, J6: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
MES1: Voltmeter_DC; voltage_counter
R1, R2, R3, R4: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RP_RV: R_Potentiometer_Trim_US; Potentiometer_Bourns_3296W_Vertical
SW1, SW2: SW_DIP_x01; 2MS1T2B4M2QES
SW3: SW_DIP_x01; DS-850k
U1, U2: OKL-T_6-W12N-C; DCDC-murata-6A

Connections:
+5V: C3.1, J5.1, J6.1, U1.4 (VOUT), U1.5 (SENSE)
+5VA: C4.1, J5.3, U2.4 (VOUT), U2.5 (SENSE)
+12V: C1.1, C2.1, J1.2, J2.2, J3.2, J4.2, J6.3, R1.1, R2.1, SW3.2, U1.2 (VIN), U2.2 (VIN)
GND: BAT.2 (-), C1.2, C2.2, C3.2, C4.2, D1.2 (A), J1.1, J2.1, J3.1, J4.1, J5.2, J6.2, MES1.1 (-), SW1.1, SW2.1
unnamed: BAT.1 (+), F1.1
unnamed: D1.1 (K), F1.2, MES1.2 (+), SW3.1
unnamed: R1.2, SW1.2, U1.1 (ON/OFF_CTRL)
unnamed: R2.2, SW2.2, U2.1 (ON/OFF_CTRL)
unnamed: R3.1, U1.3 (GND), U1.7 (GND)
unnamed: CON_RV.1, CON_RV.2, R3.2
unnamed: R4.1, U2.3 (GND), U2.7 (GND)
unnamed: R4.2, RP_RV.1, RP_RV.2
unnamed: CON_RV.3, U1.6 (TRIM)
unnamed: RP_RV.3, U2.6 (TRIM)
