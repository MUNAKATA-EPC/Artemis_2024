# Repository MUNAKATA-EPC/Artemis_2024

File README.md:

# Artemis_2024

宗高アルテミス 2024シーズンリポジトリです。

OpenLeague→LightWeightと方針を転換しました。
OpenLeagueの残骸に関しては2025シーズンに向けての開発と思ってもらえればよきです。

## 最終活動結果
### 北九州ノード 
  優勝  
### 九州ブロック 
  準優勝 / 優秀プレゼンテーション賞  
### RoboCupJunior2024 JapanOpen Nagoya 
  世界大会推薦順位3位  
### RoboCup2024 Eindhoven 
  Individual 3rd Place / Top Poster & Presentation  

## リポジトリについて
・フォルダ階層をきれいにしよう  
・パス設定は相対パス基準にしよう  
・あとは動けばなんでもよし。  

## 命名規則など
・各ロボットごとにプロジェクトファイルを作成しましょう。(英字表記推奨、フォルダ名に2バイト文字は嫌じゃ！！！！)  
　ex. Project_FukuokaNode

・PlatformIO等で作成されたプロジェクトフォルダの名前は (プロジェクト名)-(開発環境) にしましょう。  
　ex. hogehoge-teensy40 hugahuga-seeeduinoxiaorp2040
 
・KiCad、Fusion360などで作成されたフォルダ、ファイルの名前は一目でわかる名前にしましょう。  
　間違ってもファイル名を"unko"とかにするなよ！！！！！(戒め)

 ## 使用ソフト
 |系統|ツール|
 |----|----|
 |ロボット設計|Autodesk Fusion 360  |
 |回路設計|KiCad 6.x (only use 6.x ver.)  |
 |プログラム開発|Microsoft Visual Studio Code <br>Arduino IDE   |

## KiCad design Project_DefencerByAsahi/Hardware/kicad_data/kicker_board/kicker_board.kicad_pcb

Parts:
C1, C4: C; C_Radial_D16.0mm_H31.5mm_P7.50mm
C2: C; C_Disc_D8.0mm_W2.5mm_P5.00mm
C3: C; C_Radial_D12.5mm_H20.0mm_P5.00mm
J2, J3, J5: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
Q2: Q_NJFET_GDS; FET(big)
R1, R4: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: XL6009

Connections:
5V: J3.1, R4.1
+12V: J2.1, U1.1 (IN+)
GND: J2.2, J3.2, U1.2 (IN-)
unnamed: C1.1, C4.1, J5.1, R1.2
unnamed: C1.2, C2.2, C3.2, C4.2, Q2.3 (S), R5.2, U1.4 (OUT-)
unnamed: C2.1, C3.1, R1.1, U1.3 (OUT+)
unnamed: J5.2, Q2.2 (D)
unnamed: Q2.1 (G), R4.2, R5.1

Notes on the sheet:
セラコン
capa

Board: 2 copper layers, 12 parts (1 on the bottom side), 8 nets, no tracks yet.

## KiCad design Project_MOMIJI/hardware/kicad_data/kicker_board/kicker_board.kicad_pcb

Parts:
D1, D2: D; D_5W_P12.70mm_Horizontal
J1, J2, J3, J5, J6: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_01x04_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Q1: Q_PMOS_GDS; Pch MOSFET
Q2: Q_NMOS_GDS; Pch MOSFET
R1, R2, R3, R4, R6, R7: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2: ILD74; フォトカプラー
U3: XL6009

Connections:
+5V: J4.4, J7.2, U2.7
+12V: J5.2, J6.2, U3.1 (IN+)
+48V: D1.1 (K), Q1.3 (S), R3.2
GND: J1.2, J2.2, J5.1, J6.1, J7.1, Q2.3 (S), R4.2, R7.1, U1.2, U2.2, U3.2 (IN-), U3.4 (OUT-)
unnamed: D1.2 (A), U3.3 (OUT+)
unnamed: D2.1 (K), J1.1, J2.1, J3.1, Q1.2 (D)
unnamed: D2.2 (A), J3.2, Q2.2 (D)
unnamed: Q1.1 (G), R3.1, U1.7
unnamed: Q2.1 (G), R6.2, R7.2
unnamed: R1.2, U1.1
unnamed: R2.2, U2.1
unnamed: R4.1, U1.8
unnamed: R6.1, U2.8
dri: J4.1, J7.3
kick_charge: J4.3, R1.1
kick_kick: J4.2, R2.1

Notes on the sheet:
to dribbler
kicker module
to main board
connectors
to power board

Board: 2 copper layers, 53.2 x 73.2 mm, 20 parts (0 on the bottom side), 16 nets.

## KiCad design Project_Testing_AkizukiMotor/Hardware/kicad_data/ballsensor_unity_board/ballsensor_unity_board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9: C; C_Disc_D5.0mm_W2.5mm_P5.00mm
J1, J2, J3, J4, J5, J6, J7, J8: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
J9, J10: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R9: 22k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1: SeeeduinoXIAO; seeeduinoXIAO

Connections:
+3.3V: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, U1.12 (3V3)
+5V: J9.1, U1.14 (5V)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, U1.13 (GND)
IR1: C1.2, R1.2, U1.3 (PA10_A2_D2)
IR2: C2.2, R2.2, U1.4 (PA11_A3_D3)
IR3: C3.2, R3.2, U1.5 (PA8_A4_D4_SDA)
IR4: C4.2, R4.2, U1.6 (PA9_A5_D5_SCL)
IR5: C5.2, R5.2, U1.7 (PB08_A6_D6_TX)
IR6: C6.2, R6.2, U1.8 (PB09_A7_D7_RX)
IR7: C7.2, R7.2, U1.9 (PA7_A8_D8_SCK)
IR8: C8.2, R8.2, U1.10 (PA5_A9_D9_MISO)
unnamed: J1.1, R1.1
unnamed: J2.1, R2.1
unnamed: J3.1, R3.1
unnamed: J4.1, R4.1
unnamed: J5.1, R5.1
unnamed: J6.1, R6.1
unnamed: J7.1, R7.1
unnamed: J8.1, R8.1
unnamed: R9.2, U1.2 (PA4_A1_D1)
OUT1: J10.2, U1.1 (PA02_A0_D0)
OUT2: C9.1, J10.1, R9.1

Board: 2 copper layers, 77.5 x 92.5 mm, 29 parts (0 on the bottom side), 22 nets.

## KiCad design Project_MOMIJI/hardware/kicad_data 2/main_board/main_board.kicad_pcb

Parts:
Brd1: SSD1306; PinSocket_1x04_P2.54mm_Vertical
C1, C2, C3, C4, C5, C6, C7, C8: C; C_Disc_D3.4mm_W2.1mm_P2.50mm
D1: D; D_5W_P12.70mm_Horizontal
J1, J6: Conn_01x05_Female; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2: Conn_01x04_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_01x06_Female; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J5: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1, R2: R_Trim; 可変抵抗
R3, R4, R5, R6, R8, R9, R11, R12, R13, R14: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: R_Potentiometer_Trim_US; 可変抵抗
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH_6mm_H7.3mm
SW5: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW6: SW_Push; SW
U1: open_mv; OpenMV
U2: Teensy4.0; Teensy_Brakeout
U3: TWELITE_UART; TWELITE UART
U4, U5, U6, U7, U8, U9, U10, U11: TSSP58038
U12: L3GD20H_module; L3GD20H_Module_KiCad6.0
U13: BNO055
U14, U15: SeeeduinoXIAO; seeeduinoXIAO

Connections:
+3V3: Brd1.2 (VCC), J1.5, J4.6, R8.2, R9.1, RV1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.1, U2.16 (3V3), U2.31 (3V3), U2.49 (3V3), U3.6 (VCC), U4.0 (Vin), U5.0 (Vin), U6.0 (Vin), U7.0 (Vin), U8.0 (Vin), U9.0 (Vin), U10.0 (Vin), U11.0 (Vin), U12.1 (VCC), U12.8 (CS), U13.1 (VIN), U14.12 (3V3), U15.12 (3V3)
+5V: D1.1 (K), J2.4, J5.1, J6.1, R1.2, R2.2, U1.2 (vin), U2.33 (VIN), U14.14 (5V), U15.14 (5V)
A1: RV1.2, U2.11 (9_OUT1C), U15.2 (PA4_A1_D1)
A2: SW6.2, U2.12 (10_CS_MQSR), U15.3 (PA10_A2_D2)
GND: Brd1.1 (GND), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J3.2, J4.5, J5.2, J6.2, RV1.3, SW1.2, U1.1 (gnd), U2.1 (GND), U2.17 (GND), U2.32 (GND), U2.47 (GND), U3.1 (GND), U4.1 (GND), U5.1 (GND), U6.1 (GND), U7.1 (GND), U8.1 (GND), U9.1 (GND), U10.1 (GND), U11.1 (GND), U12.4 (SA0), U12.5 (GND), U12.6 (INT1), U12.7 (INT2), U13.2 (GND), U14.13 (GND), U15.13 (GND)
Gyro_RX: U2.10 (8_TX2_IN1), U15.8 (PB09_A7_D7_RX)
Gyro_SCL: R8.1, U2.35 (24_A10_TX6_SCL2), U12.2 (SCL), U13.4 (SCL), U15.6 (PA9_A5_D5_SCL)
Gyro_SDA: R9.2, U2.36 (25_A11_RX6_SDA2), U12.3 (SDA), U13.3 (SDA), U15.5 (PA8_A4_D4_SDA)
Gyro_TX: U2.9 (7_RX2_OUT1A), U15.7 (PB08_A6_D6_TX)
IR1: C1.2, R3.2, U14.1 (PA02_A0_D0)
IR2: C2.2, R4.2, U14.2 (PA4_A1_D1)
IR3: C3.2, R5.2, U14.3 (PA10_A2_D2)
IR4: C4.2, R6.2, U14.4 (PA11_A3_D3)
IR5: C5.2, R11.2, U14.5 (PA8_A4_D4_SDA)
IR6: C6.2, R12.2, U14.6 (PA9_A5_D5_SCL)
IR7: C7.2, R13.2, U14.9 (PA7_A8_D8_SCK)
IR8: C8.2, R14.2, U14.10 (PA5_A9_D9_MISO)
IR_RX: U2.21 (14_A0_TX3_SPDIF_OUT), U14.8 (PB09_A7_D7_RX)
IR_TX: U2.22 (15_A1_RX3_SPDIF_IN), U14.7 (PB08_A6_D6_TX)
LCD_SCL: Brd1.3 (SCL), U2.26 (19_A5_SCL0)
LCD_SDA: Brd1.4 (SDA), U2.25 (18_A4_SDA0)
LED_kathode: J4.1, J4.2
MD_RX: J5.3, U2.3 (1_TX1_CTX2_MISO1)
unnamed: D1.2 (A), J3.1
unnamed: J4.4, R1.1
unnamed: J6.3, R2.1
unnamed: R3.1, U4.2 (OUT)
unnamed: R4.1, U5.2 (OUT)
unnamed: R5.1, U6.2 (OUT)
unnamed: R6.1, U7.2 (OUT)
unnamed: R11.1, U8.2 (OUT)
unnamed: R12.1, U9.2 (OUT)
unnamed: R13.1, U10.2 (OUT)
unnamed: R14.1, U11.2 (OUT)
unnamed: SW1.1, U1.8 (rst)
OpenMV_RX: U1.14 (rxd/sca), U2.24 (17_A3_TX4_SDA1)
OpenMV_TX: U1.13 (txo/scl), U2.23 (16_A2_RX4_SCL1)
TWELITE_RX: U2.52 (39_DAT2_TX5), U3.4 (RX)
TWELITE_TX: U2.51 (38_DAT3_RX5), U3.2 (TX)
comm1: J1.4, U2.7 (5_IN2)
comm2: J1.3, U2.8 (6_OUT1D)
comm_RX: J1.1, U2.40 (29_TX7)
comm_TX: J1.2, U2.39 (28_RX7)
dri: J2.1, U2.6 (4_BCLK2)
enter: SW3.1, U2.41 (30_CRX3)
kick_charge: J2.3, U2.5 (3_LRCLK2)
kick_kick: J2.2, U2.4 (2_OUT2)
left: SW4.1, U2.42 (31_CTX3)
line_RX: J6.4, U2.27 (20_A6_TX5_LRCLK1)
line_TX: J6.5, U2.28 (21_A7_RX5_BCLK1)
right: SW2.1, U2.43 (32_OUT1B)
toggle: SW5.1, U2.44 (33_MCLK2)
touch: J4.3, U2.45 (34_DAT1_MISO2)

Notes on the sheet:
100k
connectors
to MD
TWELITE UART
to kicker board
to power board
to communication module
to line board
SSD1306
OpenMV
Gyro module
Ball sensor
MAIN MCU
to touch board

Board: 2 copper layers, 120.0 x 123.0 mm, 50 parts (14 on the bottom side), 53 nets.

## KiCad design Project_OHKA/Hardware/KiCad/PSU/PSU.kicad_pcb

Parts:
BT1: 3Sell 1300mAh; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
C1, C2: C; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: 40v 10A; D_DO-27_P12.70mm_Horizontal
F1: 20A; fuse_socket
J1, J2: Conn_01x03_Socket; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
MES1: 24v MAX; PinHeader_1x02_P2.54mm_Vertical
R1, R2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1: R_Potentiometer_Trim_US; Potentiometer_Bourns_3296W_Vertical
SW1: 2MS1T2B4M2QES
SW2: 5A; DS-850k
U1: OKL-T_6-W12N-C; DCDC-murata-6A

Connections:
+5V: C2.1, J1.3, J2.3, R2.1, U1.4 (VOUT), U1.5 (SENSE)
+12V: C1.1, J1.1, J2.1, R1.1, SW2.2, U1.2 (VIN)
GND: BT1.2 (-), C1.2, C2.2, D1.2 (A), J1.2, J2.2, MES1.1 (-), R2.2, RV1.1, RV1.2, SW1.1, U1.3 (GND), U1.7 (GND)
unnamed: BT1.1 (+), F1.1
unnamed: D1.1 (K), F1.2, MES1.2 (+), SW2.1
unnamed: R1.2, SW1.2, U1.1 (ON/OFF_CTRL)
unnamed: RV1.3, U1.6 (TRIM)

Notes on the sheet:
Motor Driver
C1:22μF C2:10μF
R1:10k R2:1.2k
Main Board

Board: 2 copper layers, 60.4 x 20.0 mm, 13 parts (1 on the bottom side), 7 nets.

## KiCad design Project_ForKitakyusyuOpen/Hardware/kicad_data/order/main_board/main_board2.kicad_pcb

Parts:
J11: Conn_01x07_Socket; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical
J13: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J23, J25: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J27: Conn_01x05_Socket; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
R3, R4: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV2, RV3, RV4: R_Potentiometer_Trim_US; 可変抵抗
SW3, SW6, SW7, SW8: SW_DIP_x01; SW_PUSH_6mm_H7.3mm
U1: Teensy4.0; teensy 4.0
U2, U3: SeeeduinoXIAO; seeeduinoXIAO
U4: L3GD20H_Module
U5: OpenMV

Connections:
+3V3: J27.1, R3.2, R4.2, RV2.2, SW3.1, SW6.1, SW7.1, SW8.1, U1.31 (3V3), U2.12 (3V3), U3.12 (3V3), U4.1 (VCC), U4.8 (CS), U5.8 (3V3)
+5V: J11.2, J13.1, J25.1, RV3.2, RV4.2, U1.33 (VIN), U2.14 (5V), U3.14 (5V)
D1(ジャイロ): RV2.3, U2.2 (PA4_A1_D1)
D2: J23.1, U1.4 (2_OUT2)
D2(ジャイロ): SW3.2, U2.3 (PA10_A2_D2)
D3: J23.2, U1.5 (3_LRCLK2)
D4: J13.3, U1.6 (4_BCLK2)
D5: J11.1, U1.7 (5_IN2)
D6: J11.3, U1.8 (6_OUT1D)
D7: J11.5, U1.9 (7_RX2_OUT1A)
D8: J11.7, U1.10 (8_TX2_IN1)
D9: J27.5, U1.11 (9_OUT1C)
D10: SW6.2, U1.12 (10_CS_MQSR)
D11: SW7.2, U1.13 (11_MOSI_CTX1)
D12: SW8.2, U1.14 (12_MISO_MQSL)
GND: J11.4, J13.2, J25.2, J27.3, RV2.1, U1.1 (GND), U1.32 (GND), U2.13 (GND), U3.13 (GND), U4.4 (SA0), U4.5 (GND), U4.6 (INT1), U4.7 (INT2), U5.16 (GND)
LED1: J13.4, RV3.3
LED2: J11.6, RV4.3
RX1: U1.2 (0_RX1_CRX2_CS1), U2.8 (PB09_A7_D7_RX)
RX2: U1.22 (15_A1_RX3_SPDIF_IN), U5.1 (0_RX1_MOSI)
RX3: U1.23 (16_A2_RX4_SCL1), U3.8 (PB09_A7_D7_RX)
SCL0: J27.2, U1.26 (19_A5_SCL0)
SCL1: R4.1, U2.6 (PA9_A5_D5_SCL), U4.2 (SCL)
SDA0: J27.4, U1.25 (18_A4_SDA0)
SDA1: R3.1, U2.5 (PA8_A4_D4_SDA), U4.3 (SDA)
TX1: U1.3 (1_TX1_CTX2_MISO1), U2.7 (PB08_A6_D6_TX)
TX2: U1.21 (14_A0_TX3_SPDIF_OUT), U5.2 (1_TX1_MISO)
TX3: U1.24 (17_A3_TX4_SDA1), U3.7 (PB08_A6_D6_TX)

Notes on the sheet:
line_integration
リセット
ジャイロ
LCD
power
main
カメラ
touch
line
kicker
kicker_D2,3

Board: 2 copper layers, 78.0 x 98.0 mm, 19 parts (0 on the bottom side), 28 nets.
